Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-06-10T15:55:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1645(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jun 10 15:55:26 2019 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{CA7B768D-C1FE-4791-BC5C-A88DD12E5300}\ifc * Database version: 5507 * Database creation date: Mon Jun 10 15:55:25 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jun 10 15:55:25 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jun 10 15:55:26 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 1840G Shower faucet, 1840G(2018):1840G Shower faucet:344765
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - NominalDepth: 150.553 mm; NominalHeight: 130.818 mm; Projection: 127 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 1840G(2018); ConvergoRefNr: 0087-1906-0027-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 10/06/2019
Type - Green Building Properties(Type) - Backflow Prevention EN1717: HC; Customs Code: 84818011; EAN Number: 6414150089626; EN Standard: EN 817; LVI Number: 6310859; Noise Class: I (ISO 3822); RSK Number: 8232267
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/1840G; Catalog Drawing URL: http://static.oras.com/catdrw/1840G; Class: Single lever; Dimension Drawing URL: http://static.oras.com/dimdrw/1840G; FDV Document URL: http://www.oras.com/datasheet/1840G/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1840G; Group: Bath and shower faucets; Long Marketing: Bath and shower faucet. Fixed spout, diverter and aerator. Lever is equipped with an eco-button for limiting water temperature and flow-rate, which can be bypassed by pressing the button.; Manufacturer: Oras; Market: INT;FIN;EST; Model: 1840G Shower faucet; Name_en: 1840G Shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 210 x 185 x 160; Package Weight: 2.267 kg; Product Code: 1840G; Product Datasheet: http://www.oras.com/datasheet/1840G/en; Product Family: Oras Vega; Product Image URL: http://static.oras.com/image/1840G; Product URL: http://static.oras.com/1840G; Type Name: 1840G Shower faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection Size: G3/4; Eco Flow At 300kPa: 0.00670979 m3/s; Flow: Limitation option for maximum flow-rate; Flow Rate At 300kPa: 0.0116538 m3/s; HWFU: 0; Installation and Maintenance: http://static.oras.com/manual/1840G; Installation Type: Wall mounted; Installation Width: 150± 3 mm; Max. Hot Water Supply: 80 kg/K/s3; Pressure Loss With Flow 02ls: 160000 Pa; Pressure Loss With Flow 03ls: 295000 Pa; Spare Parts: http://static.oras.com/sp/1840G
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1840G(2018); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1840G; Name: 1840G Shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 190x150x130 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 1840G; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 1840G Shower faucet
Constraints - DefaultElevation: 879.526 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0757159 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.00379339 m3
Identity Data - Mark: 11
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 1840G(2018): 1840G Shower faucet; Family and Type: 1840G(2018): 1840G Shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1840G(2018): 1840G Shower faucet; Type Id: 1840G(2018): 1840G Shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
